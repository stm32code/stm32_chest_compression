# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries.2.4.0\FWlib\inc;..\..\Libraries.2.4.0\CMSIS\startup;..\..\Libraries.2.4.0\CMSIS;..\..\FreeRTOS\RTE\_FreeRTOS;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\NET\device;..\..\NET\Json;..\..\NET\Massage;..\..\NET\mqtt;..\..\NET\onenet;..\..\TASK\task;..\..\TASK\timer;..\..\TASK\git;..\..\HARDWARE\LED;..\..\HARDWARE\KEY;..\..\HARDWARE\OLED-SPI;..\..\HARDWARE\ADC;..\..\HARDWARE\RELAY;..\..\HARDWARE\EXTI;..\..\HARDWARE\USART2;..\..\HARDWARE\MPU6050;..\..\HARDWARE\MPU6050\eMPL
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../FreeRTOS/RTE/_FreeRTOS/: RTE_Components.h
    ../../FreeRTOS/RTE/RTOS/: FreeRTOSConfig.h
    ./: main.c
  group SYSTEM
    ../../SYSTEM/usart/: usart.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/delay/: delay.c
  group STARTUP
    ../../Libraries.2.4.0/CMSIS/startup/: startup_stm32f10x_hd.s
  group HAEDWARE
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/RELAY/: relay.c
    ../../HARDWARE/EXTI/: exti.c
    ../../HARDWARE/OLED-SPI/: oled.c
    ../../HARDWARE/USART2/: usart2.c
    ../../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group FWLB
    ../../Libraries.2.4.0/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../Libraries.2.4.0/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c stm32f10x_conf.h
  group NET
    ../../NET/device/: esp8266.c
    ../../NET/mqtt/: MqttKit.c
    ../../NET/onenet/: onenet.c
    ../../NET/Json/: cJSON.c
  group TASK
    ../../TASK/task/: task.c
    ../../TASK/timer/: timer.c
    ../../TASK/git/: git.c
